Commit message: IMG

File: codebase/Beta/tests/3dof.urdf (robot description, URDF)
Before this commit: robot 3_DoF_arm, 0 links, 5 joints
Joints:
- removed joint joint3
- joint ee_joint: parent link3 -> link2
- joint joint2: limit lower=-3.14159 upper=3.14159 -> lower=-3 upper=3
